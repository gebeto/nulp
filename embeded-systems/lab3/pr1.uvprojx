# Keil uVision project pr1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pr1
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\Device\ST\STM32F4xx\Source;.\CMSIS\Device\ST\STM32F4xx\Include;.\STM32F4xx_StdPeriph_Driver;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;.\User;..\display;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.1.0\CMSIS\Include;D:\Keil_v5\ARM\Pack\Keil\STM32L4xx_DFP\1.5.0\Drivers\CMSIS\Include;E:\programs\arm\ARM\CMSIS\5.5.1\CMSIS\Core\Include;C:\Apps\Keil\Arm\Packs\ARM\CMSIS\5.5.1\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f40_41xxx.s
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group User
    ./User/: main.c
  group SPeriph
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_spi.c
    ./STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h
